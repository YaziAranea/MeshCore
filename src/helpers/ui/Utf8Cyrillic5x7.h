#pragma once

#include <stdint.h>
#include <string.h>

#ifndef MESHCORE_UI_BOLD_TEXT
#define MESHCORE_UI_BOLD_TEXT 0
#endif

static const uint8_t meshcore_cyrillic_5x7[][5] = {
  {0x7E, 0x11, 0x11, 0x11, 0x7E}, // A
  {0x7F, 0x49, 0x49, 0x49, 0x31}, // Be
  {0x7F, 0x49, 0x49, 0x49, 0x36}, // Ve
  {0x7F, 0x01, 0x01, 0x01, 0x03}, // Ge
  {0x70, 0x2F, 0x21, 0x21, 0x7F}, // De
  {0x7F, 0x49, 0x49, 0x49, 0x41}, // Ie
  {0x63, 0x14, 0x7F, 0x14, 0x63}, // Zhe
  {0x41, 0x49, 0x49, 0x49, 0x36}, // Ze
  {0x7F, 0x20, 0x18, 0x04, 0x7F}, // I
  {0x7F, 0x20, 0x19, 0x04, 0x7F}, // Short I
  {0x7F, 0x08, 0x14, 0x22, 0x41}, // Ka
  {0x60, 0x1C, 0x03, 0x01, 0x7F}, // El
  {0x7F, 0x02, 0x0C, 0x02, 0x7F}, // Em
  {0x7F, 0x08, 0x08, 0x08, 0x7F}, // En
  {0x3E, 0x41, 0x41, 0x41, 0x3E}, // O
  {0x7F, 0x01, 0x01, 0x01, 0x7F}, // Pe
  {0x7F, 0x09, 0x09, 0x09, 0x06}, // Er
  {0x3E, 0x41, 0x41, 0x41, 0x22}, // Es
  {0x01, 0x01, 0x7F, 0x01, 0x01}, // Te
  {0x47, 0x28, 0x10, 0x08, 0x07}, // U
  {0x1C, 0x22, 0x7F, 0x22, 0x1C}, // Ef
  {0x63, 0x14, 0x08, 0x14, 0x63}, // Ha
  {0x7F, 0x40, 0x40, 0x7F, 0x60}, // Tse
  {0x07, 0x08, 0x08, 0x08, 0x7F}, // Che
  {0x7F, 0x40, 0x7F, 0x40, 0x7F}, // Sha
  {0x7F, 0x40, 0x7F, 0x40, 0xFF}, // Shcha
  {0x01, 0x7F, 0x48, 0x48, 0x30}, // Hard sign
  {0x7F, 0x48, 0x48, 0x30, 0x7F}, // Yery
  {0x7F, 0x48, 0x48, 0x48, 0x30}, // Soft sign
  {0x22, 0x41, 0x49, 0x49, 0x3E}, // E
  {0x7F, 0x08, 0x3E, 0x41, 0x3E}, // Yu
  {0x46, 0x29, 0x19, 0x09, 0x7F}, // Ya
};

static const uint8_t meshcore_cyrillic_lower_5x7[][5] = {
  {0x20, 0x54, 0x54, 0x54, 0x78}, // a
  {0x3C, 0x4A, 0x4A, 0x4A, 0x30}, // be
  {0x7C, 0x54, 0x54, 0x54, 0x28}, // ve
  {0x7C, 0x04, 0x04, 0x04, 0x0C}, // ge
  {0x60, 0x38, 0x24, 0x24, 0x7C}, // de
  {0x38, 0x54, 0x54, 0x54, 0x18}, // ie
  {0x44, 0x28, 0x7C, 0x28, 0x44}, // zhe
  {0x44, 0x54, 0x54, 0x54, 0x28}, // ze
  {0x7C, 0x40, 0x30, 0x08, 0x7C}, // i
  {0x7C, 0x40, 0x32, 0x09, 0x7C}, // short i
  {0x7C, 0x10, 0x28, 0x44, 0x00}, // ka
  {0x60, 0x38, 0x04, 0x04, 0x7C}, // el
  {0x7C, 0x08, 0x10, 0x08, 0x7C}, // em
  {0x7C, 0x10, 0x10, 0x10, 0x7C}, // en
  {0x38, 0x44, 0x44, 0x44, 0x38}, // o
  {0x7C, 0x04, 0x04, 0x04, 0x7C}, // pe
  {0x7C, 0x14, 0x14, 0x14, 0x08}, // er
  {0x38, 0x44, 0x44, 0x44, 0x28}, // es
  {0x04, 0x04, 0x7C, 0x04, 0x04}, // te
  {0x4C, 0x50, 0x20, 0x10, 0x0C}, // u
  {0x18, 0x24, 0x7E, 0x24, 0x18}, // ef
  {0x44, 0x28, 0x10, 0x28, 0x44}, // ha
  {0x7C, 0x40, 0x40, 0x7C, 0x60}, // tse
  {0x0C, 0x10, 0x10, 0x10, 0x7C}, // che
  {0x7C, 0x40, 0x7C, 0x40, 0x7C}, // sha
  {0x7C, 0x40, 0x7C, 0x40, 0xFC}, // shcha
  {0x04, 0x7C, 0x50, 0x50, 0x20}, // hard sign
  {0x7C, 0x50, 0x50, 0x20, 0x7C}, // yery
  {0x7C, 0x50, 0x50, 0x50, 0x20}, // soft sign
  {0x28, 0x44, 0x54, 0x54, 0x38}, // e
  {0x7C, 0x10, 0x38, 0x44, 0x38}, // yu
  {0x48, 0x34, 0x14, 0x14, 0x7C}, // ya
};

static inline uint16_t meshcoreReadUtf8Codepoint(const char*& str) {
  uint8_t c = (uint8_t)*str++;
  if (c < 0x80) return c;

  if ((c & 0xE0) == 0xC0 && (*str & 0xC0) == 0x80) {
    uint16_t cp = ((uint16_t)(c & 0x1F) << 6) | ((uint8_t)*str++ & 0x3F);
    return cp;
  }

  if ((c & 0xF0) == 0xE0) {
    for (int i = 0; i < 2 && (*str & 0xC0) == 0x80; i++) str++;
  } else if ((c & 0xF8) == 0xF0) {
    for (int i = 0; i < 3 && (*str & 0xC0) == 0x80; i++) str++;
  } else {
    while ((*str & 0xC0) == 0x80) str++;
  }
  return '?';
}

static inline const uint8_t* meshcoreCyrillicGlyph5x7(uint16_t codepoint) {
  if (codepoint == 0x0451) return meshcore_cyrillic_lower_5x7[5];
  if (codepoint >= 0x0430 && codepoint <= 0x044F) {
    return meshcore_cyrillic_lower_5x7[codepoint - 0x0430];
  }
  if (codepoint == 0x0401) return meshcore_cyrillic_5x7[5];
  if (codepoint >= 0x0410 && codepoint <= 0x042F) {
    return meshcore_cyrillic_5x7[codepoint - 0x0410];
  }
  return NULL;
}

static const uint8_t meshcore_ascii_5x7[][5] = {
  {0x00, 0x00, 0x00, 0x00, 0x00}, {0x00, 0x00, 0x5F, 0x00, 0x00}, {0x00, 0x07, 0x00, 0x07, 0x00},
  {0x14, 0x7F, 0x14, 0x7F, 0x14}, {0x24, 0x2A, 0x7F, 0x2A, 0x12}, {0x23, 0x13, 0x08, 0x64, 0x62},
  {0x36, 0x49, 0x56, 0x20, 0x50}, {0x00, 0x08, 0x07, 0x03, 0x00}, {0x00, 0x1C, 0x22, 0x41, 0x00},
  {0x00, 0x41, 0x22, 0x1C, 0x00}, {0x2A, 0x1C, 0x7F, 0x1C, 0x2A}, {0x08, 0x08, 0x3E, 0x08, 0x08},
  {0x00, 0x80, 0x70, 0x30, 0x00}, {0x08, 0x08, 0x08, 0x08, 0x08}, {0x00, 0x00, 0x60, 0x60, 0x00},
  {0x20, 0x10, 0x08, 0x04, 0x02}, {0x3E, 0x51, 0x49, 0x45, 0x3E}, {0x00, 0x42, 0x7F, 0x40, 0x00},
  {0x72, 0x49, 0x49, 0x49, 0x46}, {0x21, 0x41, 0x49, 0x4D, 0x33}, {0x18, 0x14, 0x12, 0x7F, 0x10},
  {0x27, 0x45, 0x45, 0x45, 0x39}, {0x3C, 0x4A, 0x49, 0x49, 0x31}, {0x41, 0x21, 0x11, 0x09, 0x07},
  {0x36, 0x49, 0x49, 0x49, 0x36}, {0x46, 0x49, 0x49, 0x29, 0x1E}, {0x00, 0x00, 0x14, 0x00, 0x00},
  {0x00, 0x40, 0x34, 0x00, 0x00}, {0x00, 0x08, 0x14, 0x22, 0x41}, {0x14, 0x14, 0x14, 0x14, 0x14},
  {0x00, 0x41, 0x22, 0x14, 0x08}, {0x02, 0x01, 0x59, 0x09, 0x06}, {0x3E, 0x41, 0x5D, 0x59, 0x4E},
  {0x7C, 0x12, 0x11, 0x12, 0x7C}, {0x7F, 0x49, 0x49, 0x49, 0x36}, {0x3E, 0x41, 0x41, 0x41, 0x22},
  {0x7F, 0x41, 0x41, 0x41, 0x3E}, {0x7F, 0x49, 0x49, 0x49, 0x41}, {0x7F, 0x09, 0x09, 0x09, 0x01},
  {0x3E, 0x41, 0x41, 0x51, 0x73}, {0x7F, 0x08, 0x08, 0x08, 0x7F}, {0x00, 0x41, 0x7F, 0x41, 0x00},
  {0x20, 0x40, 0x41, 0x3F, 0x01}, {0x7F, 0x08, 0x14, 0x22, 0x41}, {0x7F, 0x40, 0x40, 0x40, 0x40},
  {0x7F, 0x02, 0x1C, 0x02, 0x7F}, {0x7F, 0x04, 0x08, 0x10, 0x7F}, {0x3E, 0x41, 0x41, 0x41, 0x3E},
  {0x7F, 0x09, 0x09, 0x09, 0x06}, {0x3E, 0x41, 0x51, 0x21, 0x5E}, {0x7F, 0x09, 0x19, 0x29, 0x46},
  {0x26, 0x49, 0x49, 0x49, 0x32}, {0x03, 0x01, 0x7F, 0x01, 0x03}, {0x3F, 0x40, 0x40, 0x40, 0x3F},
  {0x1F, 0x20, 0x40, 0x20, 0x1F}, {0x3F, 0x40, 0x38, 0x40, 0x3F}, {0x63, 0x14, 0x08, 0x14, 0x63},
  {0x03, 0x04, 0x78, 0x04, 0x03}, {0x61, 0x59, 0x49, 0x4D, 0x43}, {0x00, 0x7F, 0x41, 0x41, 0x41},
  {0x02, 0x04, 0x08, 0x10, 0x20}, {0x00, 0x41, 0x41, 0x41, 0x7F}, {0x04, 0x02, 0x01, 0x02, 0x04},
  {0x40, 0x40, 0x40, 0x40, 0x40}, {0x00, 0x03, 0x07, 0x08, 0x00}, {0x20, 0x54, 0x54, 0x78, 0x40},
  {0x7F, 0x28, 0x44, 0x44, 0x38}, {0x38, 0x44, 0x44, 0x44, 0x28}, {0x38, 0x44, 0x44, 0x28, 0x7F},
  {0x38, 0x54, 0x54, 0x54, 0x18}, {0x00, 0x08, 0x7E, 0x09, 0x02}, {0x18, 0xA4, 0xA4, 0x9C, 0x78},
  {0x7F, 0x08, 0x04, 0x04, 0x78}, {0x00, 0x44, 0x7D, 0x40, 0x00}, {0x20, 0x40, 0x40, 0x3D, 0x00},
  {0x7F, 0x10, 0x28, 0x44, 0x00}, {0x00, 0x41, 0x7F, 0x40, 0x00}, {0x7C, 0x04, 0x78, 0x04, 0x78},
  {0x7C, 0x08, 0x04, 0x04, 0x78}, {0x38, 0x44, 0x44, 0x44, 0x38}, {0xFC, 0x18, 0x24, 0x24, 0x18},
  {0x18, 0x24, 0x24, 0x18, 0xFC}, {0x7C, 0x08, 0x04, 0x04, 0x08}, {0x48, 0x54, 0x54, 0x54, 0x24},
  {0x04, 0x04, 0x3F, 0x44, 0x24}, {0x3C, 0x40, 0x40, 0x20, 0x7C}, {0x1C, 0x20, 0x40, 0x20, 0x1C},
  {0x3C, 0x40, 0x30, 0x40, 0x3C}, {0x44, 0x28, 0x10, 0x28, 0x44}, {0x4C, 0x90, 0x90, 0x90, 0x7C},
  {0x44, 0x64, 0x54, 0x4C, 0x44}, {0x00, 0x08, 0x36, 0x41, 0x00}, {0x00, 0x00, 0x77, 0x00, 0x00},
  {0x00, 0x41, 0x36, 0x08, 0x00}, {0x02, 0x01, 0x02, 0x04, 0x02},
};

static inline const uint8_t* meshcoreAsciiGlyph5x7(uint16_t codepoint) {
  if (codepoint < 32 || codepoint > 126) return NULL;
  return meshcore_ascii_5x7[codepoint - 32];
}

static inline bool meshcoreCp1251Codepoint(uint8_t c, uint16_t* codepoint) {
  if (c >= 0xC0 && c <= 0xDF) {
    *codepoint = 0x0410 + (c - 0xC0);
    return true;
  }
  if (c >= 0xE0 && c <= 0xFF) {
    *codepoint = 0x0430 + (c - 0xE0);
    return true;
  }
  if (c == 0xA8) {
    *codepoint = 0x0401;
    return true;
  }
  if (c == 0xB8) {
    *codepoint = 0x0451;
    return true;
  }
  return false;
}

static inline bool meshcoreAppendUtf8Codepoint(char* dest, size_t dest_size, size_t& j, uint16_t codepoint) {
  if (codepoint < 0x80) {
    if (j + 1 >= dest_size) return false;
    dest[j++] = (char) codepoint;
    return true;
  }
  if (codepoint < 0x800) {
    if (j + 2 >= dest_size) return false;
    dest[j++] = (char) (0xC0 | (codepoint >> 6));
    dest[j++] = (char) (0x80 | (codepoint & 0x3F));
    return true;
  }
  if (j + 3 >= dest_size) return false;
  dest[j++] = (char) (0xE0 | (codepoint >> 12));
  dest[j++] = (char) (0x80 | ((codepoint >> 6) & 0x3F));
  dest[j++] = (char) (0x80 | (codepoint & 0x3F));
  return true;
}

struct MeshcoreEmojiAlias {
  const char* utf8;
  const char* ascii;
};

static const MeshcoreEmojiAlias meshcore_emoji_aliases[] = {
  {"\xE2\x9D\xA4\xEF\xB8\x8F", "<3"},
  {"\xF0\x9F\x98\x80", ":)"},
  {"\xF0\x9F\x98\x83", ":D"},
  {"\xF0\x9F\x98\x84", ":D"},
  {"\xF0\x9F\x98\x81", ":D"},
  {"\xF0\x9F\x98\x86", ":D"},
  {"\xF0\x9F\x98\x85", "xD"},
  {"\xF0\x9F\x98\x82", "xD"},
  {"\xF0\x9F\xA4\xA3", "xD"},
  {"\xF0\x9F\x99\x82", ":)"},
  {"\xF0\x9F\x99\x83", ":)"},
  {"\xF0\x9F\x98\x87", ":)"},
  {"\xF0\x9F\x98\x8B", ":)"},
  {"\xF0\x9F\x98\x8C", ":)"},
  {"\xF0\x9F\x98\x89", ";)"},
  {"\xF0\x9F\x98\x8A", "^^"},
  {"\xF0\x9F\x98\x8D", "<3"},
  {"\xF0\x9F\xA5\xB0", "[love]"},
  {"\xF0\x9F\x98\x98", "[love]"},
  {"\xF0\x9F\x98\x97", "[love]"},
  {"\xF0\x9F\x98\x99", "[love]"},
  {"\xF0\x9F\x98\x9A", "[love]"},
  {"\xF0\x9F\x98\x8E", "B)"},
  {"\xF0\x9F\x98\x90", "[meh]"},
  {"\xF0\x9F\x98\x91", "[meh]"},
  {"\xF0\x9F\x98\xB6", "[meh]"},
  {"\xF0\x9F\x99\x84", "[meh]"},
  {"\xF0\x9F\x98\x8F", "[meh]"},
  {"\xF0\x9F\x98\xAC", "[meh]"},
  {"\xF0\x9F\x98\xAE", "[wow]"},
  {"\xF0\x9F\x98\xAF", "[wow]"},
  {"\xF0\x9F\x98\xB2", "[wow]"},
  {"\xF0\x9F\x98\xB1", "[wow]"},
  {"\xF0\x9F\x98\xA8", "[wow]"},
  {"\xF0\x9F\x98\xB0", "[wow]"},
  {"\xF0\x9F\x98\xB3", "[wow]"},
  {"\xF0\x9F\x98\xB4", "[sleep]"},
  {"\xF0\x9F\x92\xA4", "[sleep]"},
  {"\xF0\x9F\x98\xAA", "[sleep]"},
  {"\xF0\x9F\x98\xA2", ":'("},
  {"\xF0\x9F\x98\xAD", "T_T"},
  {"\xE2\x98\xB9\xEF\xB8\x8F", ":'("},
  {"\xE2\x98\xB9", ":'("},
  {"\xF0\x9F\x99\x81", ":'("},
  {"\xF0\x9F\x98\x9E", ":'("},
  {"\xF0\x9F\x98\x94", ":'("},
  {"\xF0\x9F\x98\x9F", ":'("},
  {"\xF0\x9F\x98\x95", ":'("},
  {"\xF0\x9F\x98\xA3", ":'("},
  {"\xF0\x9F\x98\x96", ":'("},
  {"\xF0\x9F\x98\xAB", ":'("},
  {"\xF0\x9F\x98\xA9", ":'("},
  {"\xF0\x9F\x98\x93", ":'("},
  {"\xF0\x9F\x98\xA1", ">:("},
  {"\xF0\x9F\x98\xA0", ">:("},
  {"\xF0\x9F\xA4\xAC", ">:("},
  {"\xF0\x9F\x98\xA4", ">:("},
  {"\xF0\x9F\x98\x88", ">:("},
  {"\xF0\x9F\x91\xBF", ">:("},
  {"\xF0\x9F\xA4\xA9", "[party]"},
  {"\xF0\x9F\xA5\xB3", "[party]"},
  {"\xF0\x9F\xA4\xA0", "[party]"},
  {"\xF0\x9F\xA4\xA1", "[party]"},
  {"\xF0\x9F\xA4\xAF", "[wow]"},
  {"\xF0\x9F\x92\x80", "[skull]"},
  {"\xF0\x9F\x91\xBB", "[ghost]"},
  {"\xF0\x9F\x91\x8D", "+1"},
  {"\xF0\x9F\x91\x8E", "-1"},
  {"\xF0\x9F\x99\x8F", "pls"},
  {"\xF0\x9F\x91\x8B", "[hand]"},
  {"\xF0\x9F\x91\x8C", "[hand]"},
  {"\xE2\x9C\x8C\xEF\xB8\x8F", "[hand]"},
  {"\xE2\x9C\x8C", "[hand]"},
  {"\xF0\x9F\xA4\x9E", "[hand]"},
  {"\xF0\x9F\xA4\x9F", "[hand]"},
  {"\xF0\x9F\xA4\x98", "[hand]"},
  {"\xF0\x9F\x91\x8A", "[hand]"},
  {"\xE2\x9C\x8A", "[hand]"},
  {"\xF0\x9F\x91\x8F", "[hand]"},
  {"\xF0\x9F\xA4\x94", "[think]"},
  {"\xF0\x9F\xA7\x90", "[think]"},
  {"\xF0\x9F\x92\xAF", "100"},
  {"\xF0\x9F\xA4\x9D", "[hand]"},
  {"\xF0\x9F\xA7\x91\xE2\x80\x8D\xF0\x9F\xA6\xB1", "[me]"},
  {"\xF0\x9F\xA7\x91", "[usr]"},
  {"\xF0\x9F\x91\xA4", "[usr]"},
  {"\xF0\x9F\x91\xA5", "[grp]"},
  {"\xF0\x9F\x93\x9F", "[pg]"},
  {"\xF0\x9F\x94\x8B", "[bat]"},
  {"\xF0\x9F\x94\x8C", "[chg]"},
  {"\xE2\x9A\xA1", "[pow]"},
  {"\xF0\x9F\x92\xA1", "[lamp]"},
  {"\xF0\x9F\x8D\x80", "[ok]"},
  {"\xF0\x9F\x8F\xA2", "[ofc]"},
  {"\xF0\x9F\x8F\xAD", "[fab]"},
  {"\xF0\x9F\x8F\xAA", "[shop]"},
  {"\xF0\x9F\x8F\xA5", "[med]"},
  {"\xF0\x9F\x8F\xA6", "[bank]"},
  {"\xF0\x9F\x8F\xAB", "[sch]"},
  {"\xF0\x9F\x8F\x97\xEF\xB8\x8F", "[build]"},
  {"\xF0\x9F\x8F\x97", "[build]"},
  {"\xF0\x9F\x8F\xA1", "[home]"},
  {"\xF0\x9F\x8F\xA0", "[home]"},
  {"\xE2\x9B\xBA", "[camp]"},
  {"\xF0\x9F\xA7\xB7", "[pin]"},
  {"\xF0\x9F\x9B\x8B\xEF\xB8\x8F", "[sofa]"},
  {"\xF0\x9F\x9B\x8B", "[sofa]"},
  {"\xE2\x9A\x99\xEF\xB8\x8F", "[cfg]"},
  {"\xE2\x9A\x99", "[cfg]"},
  {"\xF0\x9F\x94\xA7", "[fix]"},
  {"\xF0\x9F\x94\xA8", "[ham]"},
  {"\xF0\x9F\xAA\x9B", "[drv]"},
  {"\xF0\x9F\x94\xA9", "[nut]"},
  {"\xF0\x9F\xAA\x8F", "[tool]"},
  {"\xE2\x9B\x8F\xEF\xB8\x8F", "[pick]"},
  {"\xE2\x9B\x8F", "[pick]"},
  {"\xE2\x9A\x92\xEF\xB8\x8F", "[tools]"},
  {"\xE2\x9A\x92", "[tools]"},
  {"\xF0\x9F\x93\xA1", "[ant]"},
  {"\xF0\x9F\x93\xB6", "[sig]"},
  {"\xF0\x9F\x93\xBB", "[radio]"},
  {"\xF0\x9F\x93\xB1", "[tel]"},
  {"\xF0\x9F\x92\xBB", "[pc]"},
  {"\xF0\x9F\x96\xA5\xEF\xB8\x8F", "[pc]"},
  {"\xF0\x9F\x96\xA5", "[pc]"},
  {"\xF0\x9F\x93\xB7", "[cam]"},
  {"\xF0\x9F\x8E\xA7", "[snd]"},
  {"\xE2\x9C\x85", "OK"},
  {"\xE2\x9D\x8C", "X"},
  {"\xE2\x9A\xA0\xEF\xB8\x8F", "!"},
  {"\xE2\x9A\xA0", "!"},
  {"\xE2\xAD\x90", "*"},
  {"\xE2\x9C\xA8", "*"},
  {"\xF0\x9F\x94\xA5", "hot"},
  {"\xF0\x9F\x9A\x80", "go"},
  {"\xF0\x9F\x93\x8D", "[loc]"},
  {"\xF0\x9F\x93\x8C", "[pin]"},
  {"\xF0\x9F\xA7\xAD", "[nav]"},
  {"\xF0\x9F\x97\xBA\xEF\xB8\x8F", "[map]"},
  {"\xF0\x9F\x97\xBA", "[map]"},
  {"\xF0\x9F\x9A\x97", "[car]"},
  {"\xF0\x9F\x9A\x99", "[car]"},
  {"\xF0\x9F\x9A\x9A", "[truck]"},
  {"\xF0\x9F\x9A\xB2", "[bike]"},
  {"\xF0\x9F\x9A\xB6", "[walk]"},
  {"\xF0\x9F\x9B\xB0\xEF\xB8\x8F", "[sat]"},
  {"\xF0\x9F\x9B\xB0", "[sat]"},
  {"\xF0\x9F\x9A\xA8", "[alarm]"},
  {"\xF0\x9F\x9A\xA7", "[warn]"},
  {"\xF0\x9F\x94\x92", "[lock]"},
  {"\xF0\x9F\x94\x93", "[open]"},
  {"\xF0\x9F\x94\x91", "[key]"},
  {"\xF0\x9F\x92\xAC", "[msg]"},
  {"\xF0\x9F\x93\xA9", "[mail]"},
  {"\xF0\x9F\x93\xA8", "[mail]"},
  {"\xF0\x9F\x93\xA6", "[box]"},
  {"\xF0\x9F\x93\x8E", "[clip]"},
  {"\xF0\x9F\x93\x9D", "[note]"},
  {"\xF0\x9F\x93\x85", "[date]"},
  {"\xE2\x8C\x9A", "[time]"},
  {"\xE2\x8F\xB0", "[time]"},
  {"\xF0\x9F\x8C\xA1\xEF\xB8\x8F", "[temp]"},
  {"\xF0\x9F\x8C\xA1", "[temp]"},
  {"\xE2\x98\x80\xEF\xB8\x8F", "[sun]"},
  {"\xE2\x98\x80", "[sun]"},
  {"\xE2\x98\x81\xEF\xB8\x8F", "[cloud]"},
  {"\xE2\x98\x81", "[cloud]"},
  {"\xE2\x98\x94", "[rain]"},
  {"\xE2\x9D\x84\xEF\xB8\x8F", "[snow]"},
  {"\xE2\x9D\x84", "[snow]"},
  {"\xE2\x9A\xBD", "[foot]"},
  {"\xF0\x9F\x8F\x80", "[basket]"},
  {"\xF0\x9F\x8E\xBE", "[tennis]"},
  {"\xE2\x9A\xBE", "[ball]"},
  {"\xF0\x9F\x8F\x90", "[ball]"},
  {"\xF0\x9F\x8F\x88", "[ball]"},
  {"\xF0\x9F\x8F\x89", "[ball]"},
  {"\xE2\x9D\xA4", "<3"},
};

static inline const char* meshcoreEmojiAlias(const char* src, size_t* consumed) {
  for (size_t i = 0; i < sizeof(meshcore_emoji_aliases) / sizeof(meshcore_emoji_aliases[0]); i++) {
    size_t len = strlen(meshcore_emoji_aliases[i].utf8);
    if (strncmp(src, meshcore_emoji_aliases[i].utf8, len) == 0) {
      *consumed = len;
      return meshcore_emoji_aliases[i].ascii;
    }
  }
  return NULL;
}

static inline bool meshcoreAppendAscii(char* dest, size_t dest_size, size_t& j, const char* text) {
  while (text && *text) {
    if (j >= dest_size - 1) return false;
    dest[j++] = *text++;
  }
  return true;
}

static inline void meshcoreCopySupportedUtf8(char* dest, const char* src, size_t dest_size) {
  if (dest_size == 0) return;
  size_t j = 0;
  while (src && *src && j < dest_size - 1) {
    size_t consumed = 0;
    const char* alias = meshcoreEmojiAlias(src, &consumed);
    if (alias) {
      if (!meshcoreAppendAscii(dest, dest_size, j, alias)) break;
      src += consumed;
      continue;
    }

    const char* start = src;
    uint8_t first = (uint8_t)*src;
    uint16_t cp = meshcoreReadUtf8Codepoint(src);
    size_t len = src - start;
    if (first >= 0x80 && cp == '?') {
      uint16_t cp1251;
      if (len == 1 && meshcoreCp1251Codepoint(first, &cp1251)) {
        src = start + 1;
        if (!meshcoreAppendUtf8Codepoint(dest, dest_size, j, cp1251)) break;
        continue;
      }
      if (strncmp(start, "\xEF\xB8\x8F", len) == 0 || strncmp(start, "\xE2\x80\x8D", len) == 0) {
        continue;
      }
      if (!meshcoreAppendAscii(dest, dest_size, j, "*")) break;
      continue;
    }
    bool supported = (cp >= 32 && cp <= 126) || cp == '\n' || cp == '\r' || meshcoreCyrillicGlyph5x7(cp) != NULL;
    if (!supported) {
      dest[j++] = '*';
      continue;
    }
    if (j + len >= dest_size) break;
    memcpy(&dest[j], start, len);
    j += len;
  }
  dest[j] = 0;
}
